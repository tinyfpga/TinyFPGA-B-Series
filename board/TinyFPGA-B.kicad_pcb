# Repository tinyfpga/TinyFPGA-B-Series

File README.md:

# TinyFPGA B2 Board
The TinyFPGA B2 board is a tiny FPGA board with a low cost per logic element and convenient USB bitstream programming capability.  It measures just 18mm x 36mm and is a perfect fit for breadboards.  

# TinyFPGA BX Repo has Moved
If you are looking for the TinyFPGA BX design files and examples, it is in a seperate repository: [TinyFPGA BX GitHub Repo](https://github.com/tinyfpga/TinyFPGA-BX).

## Features
The heart of the B-series boards is either a ICE40LP4K or ICE40LP8K FPGA from Lattice.  For full details on the ICE40 series of FPGAs you can read the [ICE40 Family Handbook](http://www.latticesemi.com/~/media/LatticeSemi/Documents/Handbooks/iCE40FamilyHandbook.pdf).

### FPGA Feature Summary
|                  | TinyFPGA B1 | TinyFPGA B2 |
|------------------|:-----------:|:-----------:|
| FPGA Chip        |  ICE40LP4K  |  ICE40LP8K  |
| Logic Cells      |    3,520    |    7,680    |
| Block RAM Bits   |   80 KBit   |   128 KBit  |
| Phase Lock Loops |      1      |      1      |
| User IO Pins     |     23      |     23      |

### Common Features
+ Small form-factor that is breadboard friendly; plenty of space on either side for connecting jumpers or components.
+ Built-in USB interface for programming new FPGA bitstreams and user data to flash.
+ [4MBit of SPI Flash](http://datasheet.octopart.com/AT25SF041-SSHD-B-Adesto-Technologies-datasheet-62342976.pdf)
  + Bootloader bitstream takes up about 1MBit, user design bitstream will take another 1MBit, the rest is free to use for other purposes.
+ 3.3v and 1.2v Regulators
  + [3.3v LDO regulator](http://datasheet.octopart.com/MIC5504-3.3YM5-TR-Micrel-datasheet-61114938.pdf) can supply up to 300ma of current.  This leaves some headroom for user peripherals.
  + [1.2v LDO regulator](http://datasheet.octopart.com/MIC5365-1.2YC5-TR-Microchip-datasheet-8324343.pdf) can supply up to 150ma of current.  More headroom for user peripherals.
+ [Ultra Low-Power 16MHz MEMs Oscillator](http://www.mouser.com/ds/2/268/20005625A-1022977.pdf)
  + Consumes 1.3ma power when active.  
  + 50ppm stability

## Building your own TinyFPGA B1 or B2 Boards
It is possible to build the TinyFPGA B-Series boards by hand in a home lab.  However, it uses tiny 0402 surface mount capacitors and resistors and the ICE40 FPGAs used are in a 81 ball BGA package with 0.4mm pitch between the balls.  It is a challenging undertaking and will most likely result in some bad assembled boards along with the good.  I have used the following with success to hand assemble the prototype boards:
+ Parts for the TinyFPGA [B1](https://octopart.com/bom-tool/v110mo4B) or [B2](https://octopart.com/bom-tool/D9LH87Em)
+ [Lead-Free Solder Paste](https://www.amazon.com/gp/product/B00HKK6XHC)
+ [Stainless Steel Solder Paste Squeegee](http://dirtypcbs.com/store/details/14/solder-paste-squeegee)
+ [TinyFPGA B-Series Solder Paste Stencil](https://www.oshstencils.com)
  + You'll need to generate the gerber files and upload the solder paste layer.  You will want the stainless steel stencil, I do not believe the polymide will work with the fine pitch BGA package.
+ [TinyFPGA B-Series PCBs](https://oshpark.com/shared_projects/jGc1k4QL)
  + These boards require tighter tolerances than OSH Park advertises.  However, I have gotten lucky with some boards from OSH Park for this project and they have worked well.
+ [Precision Tweezers](https://www.amazon.com/Precision-Anti-static-Marrywindix-Electronics-Jewelry-making/dp/B00DVIEJ14) for placing parts on the board
+ Some sort of magnifying tool for placing parts ([magnifying glasses](https://www.amazon.com/dp/B01H8808H6), [magnifying lamp](https://www.amazon.com/Brightech-LightView-SuperBright-Magnifier-Adjustable/dp/B00UW2IRJ2), microscope)
+ [Reflow Oven](http://www.whizoo.com/)
  + I was using an electric griddle to reflow the A-series boards and it worked well enough.  However I didn't bother trying that with the micro BGA package on the B-series boards and I got a reflow oven kit.  This particular kit is excellent.
+ [Lattice FPGA Programmer](https://www.ebay.com/sch/i.html?_productid=533163279) or [Arduino board](https://www.arduino.cc/)
  + You will need this to load the bootloader onto the SPI Flash.  Once the bootloader is installed you can use the Python-based programmer application to program the board over USB.
  + Look in the [`programmer_arduino`](programmer_arduino) folder to load the bootloader onto the SPI Flash using an Arduino.

## Buy TinyFPGA B1 or B2 Boards
If you don't want to go through the hassle of ordering parts, tools, and supplies and assembling the boards yourself you can order professionally assembled and tested boards from [Tindie](https://www.tindie.com/stores/tinyfpga/) or the [TinyFPGA Store](http://store.tinyfpga.com).  These boards are not hobbyist-made, they are fabricated and assembled in a professional PCB fab that manufactures and assembles many other consumer, industrial and military electronics.  They go through an automated testing and programming process to ensure the board is healthy and ready to program over USB.

## Project Directory Structure
### board
This contains a [KiCad](http://kicad.org/) project with the schematic and layout of the B-series boards.  The board is designed with 4/4mil track size/spacing and 0.2mm hole size.  BOM lists for B1 and B2 boards are available here as well.

### bootloader
FPGA boards with USB bitstream programming capability typically use an expensive USB interface chip to provide this functionality.  The TinyFPGA B-series implement the USB bitstream programming capability within the FPGA itself.  This directory contains the verilog code that implements this bootloader.  The code is organized as an [iCEcube2](http://www.latticesemi.com/iCEcube2) project.  The bootloader itself works in the same way an Arduino bootloader works.  It is the first design to boot on the FPGA, if it is connected to a USB host it waits for a new bitstream to be programmed to the SPI flash, then reboots the FPGA to load the user design from flash.  If the board is not connected to a USB host or if there is no programmer application running on the host then the bootloader will quickly timeout and load the user design.  The bootloader does not consume any FPGA resources while the user design is loaded.

### programmer
The bootloader uses a simple protocol over a generic USB serial interface.  This directory contains a Python module for interfacing with the bootloader as well as a friendly Python GUI application for selecting and programming bitstreams.

### template
This is a template iCEcube2 project for developing your own designs to program onto the board.  It takes care of pin and clock constraints.  Just edit the TinyFPGA_B.v file to add your designs module(s).

## Project Log
For more information on the development and production of the B-Series please read and follow the [TinyFPGA B-Series Project Page](https://hackaday.io/project/26848-tinyfpga-b-series) at hackaday.io.

## License
The TinyFPGA B-Series project is an open source project licensed under GPLv3.  Please see the included LICENSE file for details.  If you do wish to distribute boards derived from this open source hardware project then you must also release the source files for the boards under GPLv3.  You are free to do this, but please improve upon the original design and provide a tangible benefit for users of the board.

## KiCad design board/TinyFPGA-B.kicad_pcb

Board: 2 copper layers, 17.8 x 35.6 mm, 36 parts (2 on the bottom side), 35 nets.

Parts:
C1, C2, C3, C4: 1uF; C_0402_NoSilk
C5, C7, C8, C9, C10, C11, C16: 100nF; C_0402_NoSilk
C6, C17: 10uF; C_0603
C12, C13, C14, C15: 10nF; C_0402_NoSilk
J1, J2: CONN_01X14; Pin_Header_Straight_1x14_Pitch2.54mm
J3: USB_OTG; USB_Micro-B_Molex_47346-0001
L1: Bead; L_0603
R1: 1.5k; R_0402_NoSilk
R2, R3: 68; R_0402_NoSilk
R4: 100; R_0402_NoSilk
R5, R7: 10k; R_0402_NoSilk
R6: 100; R_0402
SW1: SW_Push; PTS_810_SMT_Switch
TP1, TP2: TEST; Measurement_Point_Round-SMD-Pad_Small
U1: iCE40-LP8K-CM81; CM81
U2: MIC5504-3.3YM5-TR; SC-70-C5
U3: DSC6001CI2A-016.0000T; CDFN3225-4LD-PL-1
U4: MIC5365-1.2YC5-TR; SC-70-C5
U5: AT25SF041-SSHD-B; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
2B: J1.5, U1.B2, U1.B3, U1.C2, U1.C3
3A: J1.8, U1.B1
3B: J1.9, U1.C1
10A: J1.10, U1.D1
10B: J1.11, U1.E1
24B: J1.12, U1.G1
54: J1.13, U1.H1
55: J1.14, U1.J1
116: J2.7, U1.A9
119: J2.10, U1.D9
141_GBIN2: J2.8, U1.D7, U1.D8, U1.E7, U1.E8
148: J2.9, U1.C9
174: J2.6, U1.A8
177: J2.5, U1.A7
185: J2.4, U1.A6
221: J1.6, U1.A2
224: J1.7, U1.A1
+1V2: C3.1, C11.1, C12.1, C13.1, J2.3, R4.2, U1.D2, U1.D3, U1.D4, U1.E2, U1.E9, U1.F1, U1.F2, U4.5
+3V3: C2.1, C4.1, C5.1, C8.1, C9.1, C10.1, C14.1, C15.1, C16.1, J2.2, R1.2, R5.1, R6.1, U1.A5, U1.B6, U1.B7, U1.B8, U1.B9, U1.C6, U1.C8, U1.H3, U1.H8, U1.J2, U1.J5, U1.J9, U2.4, U2.5, U3.1, U3.4, U4.1, U4.3, U5.8
+5V: C1.1, C17.1, J2.1, L1.1, U2.1, U2.3
CLK: J1.4, U1.B4, U1.B5, U1.C4, U1.C5, U3.3
CRESET_B: R6.2, SW1.2, TP2.1, U1.H5, U1.H6, U1.J4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, J1.1, J3.5, J3.6, R7.2, SW1.1, U1.E4, U1.E5, U1.F4, U1.F5, U1.F6, U1.F9, U2.2, U3.2, U4.2, U5.4
unnamed: C6.1, C7.1, U1.J6
unnamed: C6.2, C7.2, R4.1, U1.J7
unnamed: J3.1, L1.2
unnamed: J3.2, R3.2
unnamed: J3.3, R1.1, R2.2
unnamed: R7.1, TP1.1, U5.3
SCK: J2.12, U1.G7, U1.G8, U1.H9, U5.6
SDI: J2.13, U1.H7, U1.J8, U5.2
SDO: J2.14, U1.G5, U1.G6, U1.H4, U1.J3, U5.5
SS: J2.11, R5.2, U1.F7, U1.F8, U1.G9, U5.1
USB_N: J1.3, R3.1, U1.A4
USB_P: J1.2, R2.1, U1.A3

File board/TinyFPGA B1 BOM.xlsx:

Qty | Manufacturer | MPN | Schematic Reference | Description | Package | Polarity
1 | FCI | 10118192-0001LF | J3 | USB Micro Connector |  | pin locations only allow one correct orientation
1 | Microchip | MIC5365-1.2YC5-TR | U4 | 1.2v LDO |  | pin locations only allow one correct orientation
1 | Microchip | MIC5504-3.3YM5-TR | U2 | 3.3v LDO |  | pin locations only allow one correct orientation
4 | Murata | GRM155R61A105KE15D | C1, C2, C3, C4 | 1uF Ceramic Capacitor, 10V, X7R, 10% | 0402 | no polarity
1 | Lattice Semiconductor | ICE40LP4K-CM81 | U1 | FPGA | CM81 | circle on package at pin 1,
1 | Microchip | DSC6001CI2A-016.0000T or DSC6001CI2A-016.0000 | U3 | 16MHz Clock | CDFN3225-4LD-PL-1 | circle on package at pin 1
1 | Adesto Technologies | AT25SF041-SSHD-B | U5 | 4MBit SPI Flash | SOIC-8 3.9x4.9mm Pitch1.27mm | slight divot on package at pin 1
1 | C&K Components | PTS810 SJM 250 SMTR LFS | SW1 | Reset/Program Button |  | button is slightly wider in one dimension
3 | Vishay | CRCW040210K0FKED | R5, R6, R7 | 10k resistor, 1% tolerance, 1/16 watt | 0402 | no polarity
1 | KOA | RK73H1ETTP1000F | R4 | 100ohm resistor, 1% tolerance, 1/10 watt | 0402 | no polarity
2 | Panasonic | ERJ-2RKF68R0X | R2, R3 | 68ohm resistor, 1% tolerance, 1/10 watt | 0402 | no polarity
1 | Bourns | CR0402-FX-1501GLF | R1 | 1.5k resistor, 1% tolerance, 1/16 watt | 0402 | no polarity
4 | Wurth Electronics | 885012205050 | C12, C13, C14, C15 | 10nF Ceramic Capacitor, 25V, X7R, 10% | 0402 | no polarity
7 | Wurth Electronics | 885012105018 | C5, C7, C8, C9, C10, C11, C16 | 100nF Ceramic Capacitor, 25V, X5R, 10% | 0402 | no polarity
2 | TDK | C1608X5R0J106M080AB | C6, C17 | 10uF Ceramic Capacitor, 6.3V, X5R, 20% | 0603 | no polarity
1 | Murata | BLM18PG300SN1D | L1 | Ferrite Bead, 30ohm@100MHz impedance, 50mOhm DC resistance | 0603 | no polarity
 |  | Green items may be substituted with parts that have identical or better specifi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
 |  | Red items may not be substituted with different part numbers

## Commit log

2017-07-08 first commit of the schematic, pcb layout, and BOM files
2017-07-08 adding TinyFPGA B-Series programmer source code
2017-07-08 adding bootloader verilog and project files for use with icecube
2017-07-08 ignore vim files and build files
2017-07-09 Update README.md
    added extra information about the board itself as well as high level parts, tools, and supplies necessary to build your own.
2017-07-09 ignore KiCad backup files and gerbers
2017-07-09 added template iCEcube2 project to use as starting point for user designs
2017-07-15 nak acm status endpoint requests
2017-08-05 updated USB VID:PID to 1209:2100
2017-08-28 testing updates, new PID for programmer, NAK fix
2017-08-28 added DFT firmware and bootloader multi-boot image project
2017-09-09 Delete tinyfpgab-programmer.py
    the GUI has been moved to its own github repo: https://github.com/tinyfpga/TinyFPGA-Programmer-Application
2017-10-07 updates for manufacturing, schematic pdf
2017-10-10 added programmer cli, added icestorm template
2017-10-10 Update Makefile
2017-10-17 workaround bug in bootloader that macos was hitting almost all the time
2017-10-18 more stability fixes for MacOS
2017-10-28 programmer: import serial only if needed
2017-10-28 programmer: better output on program verify error
2017-10-28 programmer: _erase check for all valid lengths
2017-10-28 programmer: fix computation issue in erase
    This was occurring when the area to erase was less than 4096 bytes, did not
    start on a 4096 byte block, but did end on a 4096 block. In that case, the 4096
    block just after was read and re-written for nothing (it was not even erased!)
2017-10-28 programmer: add tests
2017-10-28 programmer: PEP8
2017-10-28 programmer: make executable, change line endings
    To be able to run under *nix systems, line endings should be \n and not \r\n.
2017-10-28 programmer: code refactoring
2017-10-29 programmer: remove useless h function
2017-10-29 programmer: allow to specify address to write to
2017-10-29 programmer: allow to specify vendor:product
2017-10-29 Add Arduino programmer
2017-10-29 adding support for travis-ci and tox
2017-10-30 Improve travis-ci build
2017-11-04 untested fix for linux stability issues
2017-11-04 tested on linux, added robust retry mechanism for 4k pages
2017-11-05 update retry count
2017-11-05 fixed broken tests and bug found by unit test
2017-11-05 restructured programmer into a python package
2017-11-05 some cleanups
2017-11-26 Fix VID/PID containing letters not being matched
    On Linux, comports() returns an all uppercase result, so any programmer
    which vid/pid contains letters is no going to match
2017-12-08 comment out debug line
2018-01-10 Add exit(1) if programming is not successful
2018-01-10 Fix setup indentation
2018-01-10 Manage Serial exceptions
2018-01-10 Avoid exception "TypeError: ord() expected a character, but string of length 0 found"
2018-01-10 Check if the program option exists
2018-02-18 Initial migration to python3
2018-02-18 Tox changed to py36. Success in passing the tests
2018-03-03 Make tests compatible with py2/3
2018-03-03 Pass all tests for Python 2 and 3
2018-03-03 Change from py35 to py36
2018-04-01 updated python module version for tinyfpgab
2021-11-10 Update README.md
    https://forum.kicad.info/t/warning-avoid-all-links-to-kicad-pcb-org-use-kicad-org/31521
